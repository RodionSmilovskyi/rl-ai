Commit message: Updated drone weight to 421 gramm

File: src/assets/drone.urdf (robot description, URDF)
Before this commit: robot volador_vx35_280g, 5 links, 4 joints
Links:
- link body_link: mass 0.216 -> 0.357
