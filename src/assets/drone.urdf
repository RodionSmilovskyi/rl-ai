Commit message: Integrated flight controller from drone-control-center, adjusted observation space and removed obsolete code

File: src/assets/drone.urdf (robot description, URDF)
Before this commit: robot volador_vx35_280g, 5 links, 4 joints
Links:
- link body_link: mass 0.357 -> 0.411
